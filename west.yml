## west.yml
```yaml
manifest:
  projects:
    - name: my-basic-hal
      url: https://github.com/Fo-Zi/my-basic-HAL
      revision: v0.3.0
      path: hal-interface
```
